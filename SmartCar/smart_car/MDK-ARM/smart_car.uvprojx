# Keil uVision project smart_car.uvprojx, settings and files
target smart_car (5060960::V5.06 update 7 (build 960)::.\2.ARM_Compiler_5.06u7)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: smart_car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=188,111,68,546
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP;../OLED_Driver;../COM;../LVGL_Driver;../LVGL_Driver/src;../LVGL_App;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Application/User/Core
    ../Core/Inc/: spi.h
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_spi.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group APP
    ../APP/: key.c key.h servo.c servo.h motor.c motor.h encoder.c encoder.h pid.h pid.c ws2812.c ws2812.h battery.c battery.h ntc.c ntc.h bh1721.c bh1721.h eeprom.c eeprom.h mpu6050.c mpu6050.h track.c track.h ps2.c ps2.h
  group OLED_Driver
    ../OLED_Driver/: oled.c oled.h oledfont.h lvgl_port.c lvgl_port.h
  group COM
    ../COM/: delay.c delay.h system_bsp.h soft_i2c.c soft_i2c.h
  group LVGL_Driver
    ../LVGL_Driver/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ../LVGL_Driver/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
    ../LVGL_Driver/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL_Driver/src/extra/: lv_extra.c
    ../LVGL_Driver/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../LVGL_Driver/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
    ../LVGL_Driver/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
    ../LVGL_Driver/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group LVGL_App
    ../LVGL_Driver/: lv_conf.h
    ../LVGL_App/: emotion_display.c emotion_display.h font_awesome_30_1.c font_awesome_30_1.h font_awesome_symbols.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
